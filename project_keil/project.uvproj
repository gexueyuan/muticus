# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f429
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,STM32F429_439xx,USE_STM32F429I_DISCO,USE_USB_OTG_HS ,USE_EMBEDDED_PHY,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --c99 --diag-suppress 111
  c include: .;..\application;..\driver;..\bsp;..\os_osal;..\os_rtthread\include;..\os_rtthread\components\init;..\os_rtthread\components\drivers\include;..\os_rtthread\components\drivers\include\drivers;..\os_rtthread\components\finsh;..\os_rtthread\libcpu\arm\common;..\os_rtthread\libcpu\arm\cortex-m4;..\lib_stm32fxxx\CMSIS\Include;..\lib_stm32fxxx\CMSIS\STM32F429\Include;..\lib_stm32fxxx\STM32F4xx_StdPeriph_Driver\inc;..\lib_stm32fxxx\STM32_USB_Device_Library\Class\audio\inc;..\lib_stm32fxxx\STM32_USB_Device_Library\Class\cdc\inc;..\lib_stm32fxxx\STM32_USB_Device_Library\Class\dfu\inc;..\lib_stm32fxxx\STM32_USB_Device_Library\Class\hid\inc;..\lib_stm32fxxx\STM32_USB_Device_Library\Class\msc\inc;..\lib_stm32fxxx\STM32_USB_Device_Library\Core\inc;..\lib_stm32fxxx\STM32_USB_HOST_Library\Class\HID\inc;..\lib_stm32fxxx\STM32_USB_HOST_Library\Class\MSC\inc;..\lib_stm32fxxx\STM32_USB_HOST_Library\Core\inc;..\lib_stm32fxxx\STM32_USB_OTG_Driver\inc;..\driver\wifi\chips\ralink\include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Application
    ../application/: application.c startup.c cv_sys_main.c cv_sys_manager.c cv_sys_param.c cv_vam_api.c cv_vam_lip.c cv_vam_lip_nmea.c cv_vam_main.c cv_vam_mda.c cv_vam_rcp.c cv_vam_util.c cv_vam_vsm.c cv_vsa_main.c cv_wnet_dsmp.c cv_wnet_fp.c cv_wnet_llc.c cv_wnet_main.c cv_lcd.c app_wnet.c dat_lcd_alarm.c dat_lcd_font.c app_interface.c cv_sys_sound_play.c app_tsc.c
  group Driver
    ../driver/: board.c stm32f4xx_it.c cv_drv_fls.c cv_drv_gps.c cv_drv_gsnr.c cv_drv_key.c cv_drv_led.c lcd_log.c cv_drv_qc.c drv_sdram.c drv_lcd.c drv_wnet.c drv_main.c drv_gnss.c drv_tsc.c cv_drv_voc.c
  group Bsp
    ../bsp/: bma250e.c i2c.c led.c lsm303dlhc.c platform.c spi.c usart.c bsp_sdram_IS42S16400J.c bsp_gnss_MAX7Q.c bsp_lcd_HX8257.c stm32f429i_discovery_ioe.c syn6288.c ublox.c bsp_tsc_STMPE811.c
  group Os_osal
    ../os_osal/: cv_osal_debug.c cv_osal_dmem.c
  group Os_rtthread_src
    ../os_rtthread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group Os_rtthread_libcpu
    ../os_rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../os_rtthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Os_rtthread_comp_init
    ../os_rtthread/components/init/: components.c
  group Os_rtthread_comp_finsh
    ../os_rtthread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Os_rtthread_comp_drivers
    ../os_rtthread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../os_rtthread/components/drivers/serial/: serial.c
    ../os_rtthread/components/drivers/spi/: spi_core.c spi_dev.c
    ../os_rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group Lib_stm32fxxx_stdperiph
    ../lib_stm32fxxx/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../lib_stm32fxxx/CMSIS/DSP_Lib/: arm_cortexM4lf_math.lib
  group Lib_stm32fxxx_cmsis
    ../lib_stm32fxxx/CMSIS/STM32F429/Source/: system_stm32f4xx.c startup_stm32f429_439xx.s
